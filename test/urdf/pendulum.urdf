Commit message: adjust pendulum properties

File: test/urdf/pendulum.urdf (robot description, URDF)
Before this commit: robot Pendulum, 2 links, 1 joints
Links:
- link upper_link: geometry visual cylinder length=1.0 radius=.05
